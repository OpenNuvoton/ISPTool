# Keil uVision project ISP_Bridge_Lib.uvproj, settings and files
target ISP_Bridge_Lib (ARM-ADS)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: ISP_Bridge (library)
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: EXPORT_LIB
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\Library\StdDriver\inc;..\..\HAL_Driver;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480_user.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Library
    ../../../Library/StdDriver/src/: can.c usci_i2c.c
  group HAL_Driver
    ../../HAL_Driver/: hal_sys.c hal_spi.c hal_usci_i2c.c hal_hsusbd.c hal_can_isp.c hal_rs485.c
  group User
    ../: isp_bridge.c
