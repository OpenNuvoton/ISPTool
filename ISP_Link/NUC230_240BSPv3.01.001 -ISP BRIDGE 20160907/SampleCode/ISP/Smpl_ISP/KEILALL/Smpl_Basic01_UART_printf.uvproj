# Keil uVision project Smpl_Basic01_UART_printf.uvproj, settings and files
target UART_Printf (ARM-ADS)
  device: NUC240VE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Smpl_Basic01_UART_printf
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC230_240\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\ISP_BSP\inc;..\FATFS\src;..\
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC230_240.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/ARM/: startup_NUC230_240.s
  group Libraries
    ../FATFS/src/: diskio.c ff.c
    ../../../../Library/StdDriver/src/: acmp.c adc.c can.c clk.c crc.c ebi.c fmc.c gpio.c i2c.c i2s.c pdma.c ps2.c pwm.c retarget.c rtc.c sc.c scuart.c spi.c sys.c timer.c uart.c usbd.c wdt.c wwdt.c
    ../FATFS/src/option/: ccsbcs.c
  group User
    ../: main.c cmd.c ISP_FILE_ACCESS.c ISP_SDCARD.c ISP_CAN0.C ISP_ACMP_ADC.c ISP_I2C0.C ISP_KEY_BUZZER.C ISP_LCD.C ISP_SPI_FLASH.c ISP_SPI2.c ISP_UART0.c descriptors.c ISP_UART1WIRE.C HID_Transfer_and_MSC.c
    ../../../../Library/ISP_BSP/src/: ISP_BSP.C
