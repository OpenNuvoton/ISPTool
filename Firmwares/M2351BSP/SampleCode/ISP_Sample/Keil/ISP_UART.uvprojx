# Keil uVision project ISP_UART.uvprojx, settings and files
target ISP_UART (6070000::V6.7::.\ARMCLANG)
  device: M2351KIAAEES Nuvoton
  pack: Nuvoton.NuMicro_DFP_M23.1.0.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x00080000) CPUTYPE("ARMV8MBL") TZ CLOCK(12000000) ESEL ELITTLE
  output: M2351_ISP_UART0_PB12_PB13
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\..\Library\Device\Nuvoton\M2351\Include;..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --map --first='startup_M2351.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
    ../../../Library/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.s
  group User
    ../: fmc_user.c isp_user.c
    ../ISP_UART/: main.c uart_transfer.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c clk.c MKROMLib_Keil.lib
