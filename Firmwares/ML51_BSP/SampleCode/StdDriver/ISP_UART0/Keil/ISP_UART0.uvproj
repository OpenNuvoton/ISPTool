# Keil uVision project ISP_UART0.uvproj, settings and files
target UART_mode_2 (MCS-51)
  device: ML51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: ISP_UART0 +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=1 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source
    ../: main.c
  group Common
    ../../../../Library/StdDriver/src/: isp_uart0.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
