# Keil uVision project ISP_UART.uvproj, settings and files
target ISP_UART (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: M058SSAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: M058S_ISP_UART0_P30_P31
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M058S\Include;..\..\..\..\Library\StdDriver\inc
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M058S.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M058S/Source/: system_M058S.c
    ../../../../Library/Device/Nuvoton/M058S/Source/ARM/: startup_M058S.s
  group User
    ../: main.c FMC_USER.c ISP_USER.c uart_transfer.c targetdev.c
