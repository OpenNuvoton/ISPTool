# Keil uVision project ISP_UART.uvproj, settings and files
target ISP_UART (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NUC1261SG4AE Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: NUC1261_ISP_UART0_PA2_PA3
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Library\Device\Nuvoton\NUC1261\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\CMSIS\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC1261.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC1261/Source/ARM/: startup_NUC1261.s
    ../../../Library/Device/Nuvoton/NUC1261/Source/: system_NUC1261.c
  group User
    ../: fmc_user.c isp_user.c targetdev.c
    ../ISP_UART/: main.c uart_transfer.c
