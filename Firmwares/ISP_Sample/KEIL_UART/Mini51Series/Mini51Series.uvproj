# Keil uVision project Mini51Series.uvproj, settings and files
target Mini51Series (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: (Generic) Mini51 Series Nuvoton
  cpu: CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: Mini51DE_ISP_UART0_P12_P13
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_MINI51
  c include: ..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\Mini51Series\Include;..\..\Library\StdDriver\Mini51Series\inc
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  link misc: --map --first='startup_Mini51Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
    ../../Library/Device/Nuvoton/Mini51Series/Source/ARM/: startup_Mini51Series.s
  group User
    ../../: main_uart.c fmc_user.c isp_user.c uart_transfer.c targetdev.c
