# Keil uVision project Nano1X2Series.uvproj, settings and files
target Nano1X2Series (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: NANO112VC2AN Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: NANO102_112_ISP_UART0_PB0_PB1
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_NANO1X2
  c include: ..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\Nano1X2Series\Include;..\..\Library\StdDriver\Nano1X2Series\inc
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_Nano1X2Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/Nano1X2Series/Source/: system_Nano1X2Series.c
    ../../Library/Device/Nuvoton/Nano1X2Series/Source/ARM/: startup_Nano1X2Series.s
  group User
    ../../: main_uart.c fmc_user.c isp_user.c targetdev.c uart_transfer.c
  group Libraries
    ../../Library/StdDriver/Nano1X2Series/src/: sys.c clk.c
