# Keil uVision project Nano100BSeries.uvproj, settings and files
target Nano100BSeries (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: (Generic) Mini51 Series Nuvoton
  cpu: CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: NANO100B_ISP_UART0_PA14_PA15
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_NANO100B
  c include: ..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\Nano100BSeries\Include;..\..\Library\StdDriver\Nano100BSeries\inc
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  link misc: --map --first='startup_Nano100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/Nano100BSeries/Source/: system_Nano100Series.c
    ../../Library/Device/Nuvoton/Nano100BSeries/Source/ARM/: startup_Nano100Series.s
  group User
    ../../: main.c FMC_USER.c ISP_USER.c uart_transfer.c targetdev.c
