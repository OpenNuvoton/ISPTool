# Keil uVision project Nano103.uvproj, settings and files
target Nano103 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: NANO103SD3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: NANO103_ISP_UART0_PB0_PB1
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_NANO103
  c include: ..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\Nano103\Include;..\..\Library\StdDriver\Nano103\inc
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano103.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/Nano103/Source/: system_Nano103.c
    ../../Library/Device/Nuvoton/Nano103/Source/ARM/: startup_Nano103.s
  group User
    ../../: main_uart.c FMC_USER.c ISP_USER.c uart_transfer.c targetdev.c
  group Libraries
    ../../Library/StdDriver/Nano103/src/: sys.c clk.c uart.c
