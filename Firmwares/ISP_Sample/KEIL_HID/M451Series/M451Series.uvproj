# Keil uVision project M451Series.uvproj, settings and files
target M451Series (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: M453VG6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: M451_ISP_HID_PB6
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: TARGET_M451
  c include: .\;..\..\Library\CMSIS\Include;..\..\Library\StdDriver\M451Series\inc;..\..\Library\Device\Nuvoton\M451Series\Include;..\..\hid_transfer\M451Series
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M451Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
    ../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
  group User
    ../../hid_transfer/M451Series/: descriptors.c hid_transfer.c usbd_user.c
    ../../: main_hid.c FMC_USER.c ISP_USER.c targetdev.c
  group Library
    ../../Library/StdDriver/M451Series/src/: clk.c
