# Keil uVision project NUC121.uvproj, settings and files
target NUC121 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: NUC121SC2AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: NUC121_ISP_HID_PB0
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: TARGET_NUC121
  c include: .\;..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\NUC121\Include;..\..\Library\StdDriver\NUC121\inc;..\..\hid_transfer\NUC121
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC121.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/NUC121/Source/: system_NUC121.c
    ../../Library/Device/Nuvoton/NUC121/Source/ARM/: startup_NUC121.s
  group User
    ../../: main_hid.c FMC_USER.c ISP_USER.c targetdev.c
    ../../hid_transfer/NUC121/: descriptors.c hid_transfer.c
  group Library
    ../../Library/StdDriver/NUC121/src/: usbd.c sys.c clk.c
