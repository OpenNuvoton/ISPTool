# Keil uVision project NUC472_442.uvproj, settings and files
target NUC472_442 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: NUC472HI8AE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: NUC472_442_ISP_HID_PB15
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_NUC472_442
  c include: ..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\NUC472_442\Include;..\..\Library\StdDriver\NUC472_442\inc;..\..\hid_transfer\NUC472_442
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_NUC472_442.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group User
    ../../: main_hid.c FMC_USER.c ISP_USER.c targetdev.c
    ../../hid_transfer/NUC472_442/: descriptors.c hid_transfer.c
  group Library
    ../../Library/StdDriver/NUC472_442/src/: clk.c sys.c usbd.c uart.c retarget.c fmc.c
