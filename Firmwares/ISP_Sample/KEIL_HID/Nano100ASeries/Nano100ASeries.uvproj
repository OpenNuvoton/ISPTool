# Keil uVision project Nano100ASeries.uvproj, settings and files
target Nano100ASeries (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: NANO100VD3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: NANO100A_ISP_HID_PB15
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: TARGET_NANO100A
  c include: .\;..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\Nano100ASeries\Include;..\..\Library\StdDriver\Nano100ASeries\inc;..\..\hid_transfer\Nano100ASeries
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/Nano100ASeries/Source/: system_Nano100Series.c
    ../../Library/Device/Nuvoton/Nano100ASeries/Source/ARM/: startup_Nano100Series.s
  group User
    ../../hid_transfer/Nano100ASeries/: descriptors.c hid_transfer.c
    ../../: FMC_USER.c ISP_USER.c targetdev.c main_hid.c
  group Library
    ../../Library/StdDriver/Nano100ASeries/src/: clk.c usbd.c
