# Keil uVision project NUC123.uvproj, settings and files
target NUC123 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: NUC123SD4AN0 Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: NUC123_ISP_HID_PB14
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: TARGET_NUC123
  c include: .\;..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\NUC123\Include;..\..\Library\StdDriver\NUC123\inc;..\..\hid_transfer\NUC123
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC123.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/NUC123/Source/: system_NUC123.c
    ../../Library/Device/Nuvoton/NUC123/Source/ARM/: startup_NUC123.s
  group User
    ../../hid_transfer/NUC123/: descriptors.c hid_transfer.c
    ../../: main_hid.c fmc_user.c isp_user.c targetdev.c
  group Library
    ../../Library/StdDriver/NUC123/src/: usbd.c
