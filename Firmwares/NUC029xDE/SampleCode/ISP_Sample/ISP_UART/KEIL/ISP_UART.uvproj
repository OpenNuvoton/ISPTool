# Keil uVision project ISP_UART.uvproj, settings and files
target ISP_UART (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NUC029SDE Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x10FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: NUC029xDE_ISP_UART0_PB0_PB1
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC029xDE\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_NUC029xDE.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xDE/Source/ARM/: startup_NUC029xDE.s
    ../../../../Library/Device/Nuvoton/NUC029xDE/Source/: system_NUC029xDE.c
  group Library
    ../: FMC_USER.c ISP_USER.c targetdev.c uart_transfer.c
  group User
    ../: main.c
