# Keil uVision project ISP_USCI_UART.uvproj, settings and files
target ISP_USCI_UART (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NM1120EC1AE Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: NM1120_ISP_USCI_UART0_PD5_PD6
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NM1120\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_NM1120.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NM1120/Source/: system_NM1120.c
    ../../../../Library/Device/Nuvoton/NM1120/Source/ARM/: startup_NM1120.s
  group User
    ../: main.c fmc_user.c isp_user.c targetdev.c usci_uart_transfer.c
