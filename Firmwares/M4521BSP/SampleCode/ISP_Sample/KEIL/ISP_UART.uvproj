# Keil uVision project ISP_UART.uvproj, settings and files
target ISP_UART (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M4521RE6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: M4521_ISP_UART0_PD0_PD1
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Library\Device\Nuvoton\M4521\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\CMSIS\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M4521.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M4521/Source/: system_M4521.c
    ../../../Library/Device/Nuvoton/M4521/Source/ARM/: startup_M4521.s
  group User
    ../: targetdev.c fmc_user.c isp_user.c
    ../ISP_UART/: main.c
