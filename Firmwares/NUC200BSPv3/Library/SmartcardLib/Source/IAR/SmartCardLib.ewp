# IAR project SmartCardLib.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC200AE series Nuvoton NUC200AE series (NUC230AE,NUC240AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..; ..\..\..\Device\Nuvoton\NUC200Series\Include; ..\..\..\StdDriver\inc; ..\..\..\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  postbuild: cmd.exe /C copy /Y "Release\Exe\SmartCardLib.a" "..\..\SmartCardLib_IAR.a"
  ILINK.IlinkOutputFile: SmartCardLib.out
  group Source Files
    ../: sclib_api.c sclib_t0protocol.c sclib_t1protocol.c sclib_util.c
