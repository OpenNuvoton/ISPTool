# Keil uVision project ISP_UART.uvproj, settings and files
target ISP_UART (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: I91032 Nuvoton
  cpu: IRAM(0x20000000-0x200017FF) IROM(0-0x0FFFF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: ISD9000_ISP_UART0_PA10_PA11
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\ISD9000\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --map --first='startup_isd9000_keil.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/ISD9000/Source/: system_ISD9000.c
    ../: startup_ISD9000_keil.s
  group User
    ../: main.c FMC_USER.c ISP_USER.c targetdev.c uart_transfer.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c
